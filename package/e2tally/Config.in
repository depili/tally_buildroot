## package/e2tally/Config.in
```kconfig
config BR2_PACKAGE_E2TALLY
        bool "e2tally"
        help
          E2 Tally software
```
